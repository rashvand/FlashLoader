# IAR project FlashSTM32H7xx_QSPI.ewp, settings and files
configuration STM32H7xx_QSPI_MICRON (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; ; HAL\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashSTM32H7xx_QSPI.bin
  ILINK.IlinkOutputFile: Flash$CONFIG_NAME$.out
  ILINK.IlinkIcfFile: FlashSTM32H7xx.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashSTM32H7xx_QSPI.c
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group HAL
    HAL/: stm32h7xx_hal_cortex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_qspi.c
  group Other
    ./: FlashSTM32H7xx_QSPI.mac
