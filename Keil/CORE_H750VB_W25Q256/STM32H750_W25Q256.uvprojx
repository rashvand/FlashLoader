# Keil uVision project STM32H750_W25Q256.uvprojx, settings and files
target CORE_H750VB_W25Q256 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CORE_H750VB_W25Q256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: v6Lang=1 v6LangP=1
  c define: W25Q256JV, STM32H750xx
  c misc: --diag_suppress=66
  c include: ..\STM32H750_W25Q64;.\devices\SYSTEM\sys;.\devices\HARDWARE\QSPI;.\devices\HARDWARE\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group HARDWARE
    ./devices/HARDWARE/QSPI/: qspi.c qspi.h
    ./devices/HARDWARE/W25QXX/: w25qxx.c w25qxx.h
  group SYSTEM
    ./devices/SYSTEM/sys/: sys.c sys.h
software components: CMSIS:CORE 5.1.2
